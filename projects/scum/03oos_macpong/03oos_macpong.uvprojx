# Keil uVision project 03oos_macpong.uvprojx, settings and files
target Target SCuM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 03oos_macpong +hex
  AfterMake: fromelf --bin .\Objects\03oos_macpong.axf -o .\Objects\03oos_macpong.bin
  AfterMake: fromelf -cvf .\Objects\03oos_macpong.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\..\..\bsp\boards;..\..\..\bsp\boards\scum;..\..\..\drivers\common;..\..\..\inc;..\..\..\openstack\02a-MAClow;..\..\..\openstack\02b-MAChigh;..\..\..\openstack\03a-IPHC;..\..\..\openstack\03b-IPv6;..\..\..\openstack\04-TRAN;..\..\..\openstack\cross-layers;..\..\..\kernel;..\..\..\openapps;..\..\..\openstack;..\..\..\bsp\boards\common
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../../common/03oos_macpong/: 03oos_macpong.c
  group boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h uart.h radio.h sctimer.h
  group scum
    ../../../bsp/boards/scum/: cm0dsasm.s leds.c memory_map.h board_info.h board.c uart.c debugpins.c radio.c eui64.c sctimer.c scm3_hardware_interface.c scm3_hardware_interface.h
  group drivers
    ../../../drivers/common/: opentimers.c openhdlc.c openserial.c
  group inc
    ../../../inc/: opendefs.h
  group stack_initial
    ../../../openstack/: openstack.c openstack.h
  group 02a-MAClow
    ../../../openstack/02a-MAClow/: IEEE802154.c IEEE802154_security.c IEEE802154E.c topology.c
  group 02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c schedule.c msf.c sixtop.c
  group cross-layers
    ../../../openstack/cross-layers/: idmanager.c openqueue.c openrandom.c packetfunctions.c
  group kernel
    ../../../kernel/openos/: scheduler.c
